do_populate_sysroot[depends] += "virtual/mesa:do_populate_sysroot"

PROVIDES = "virtual/libgles2"
